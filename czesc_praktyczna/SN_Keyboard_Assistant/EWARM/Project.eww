<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SN_Keyboard_assistant.ewp</path>
  </project>
  <batchBuild />
</workspace>
